<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FISH_STM32F4_407vg_Disco_ASM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


