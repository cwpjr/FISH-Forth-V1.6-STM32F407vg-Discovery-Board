# IAR project FISH_STM32F4_407vg_Disco_ASM.ewp, settings and files
configuration STM32F4_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FISH_PubRel_WORDSET; FISH_Debug_WORDSET; STM32F4_XRC08_168MHZ
  OBJCOPY.OOCOutputFile: FISH_STM32F4_DISCO_Debug_ddmmyyyy_hhmmss.v1.6.hex
  ILINK.IlinkOutputFile: FISH_STM32F4_DISCO_Debug_ddmmyyyy_hhmmss.v1.6.out
  ILINK.IlinkIcfFile: stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F4_PubRel (ARM)
  as the first configuration, except:
  General.FPU2: 4
  AARM.ADefines: FISH_PubRel_WORDSET; STM32F4_XRC08_168MHZ
  OBJCOPY.OOCOutputFile: FISH_FORTH_STM32F4_Disco_PUBREL_RM_v1.6.hex
  ILINK.IlinkOutputFile: FISH_FORTH_STM32F4_Disco_PUBREL_RM_v1.6.out
  ILINK.IlinkIcfFile: C:\Documents and Settings\cw\AllForth\AllFISH\FISH IAR\FISH_STM32F4_407vg_Disco_Port\stm32f407xG.icf
configuration STM32F205RC-STM118mhz (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F205RC ST STM32F205RC
  General.CoreVariant: 38
  AARM.ADefines: FISH_PubRel_WORDSET; STM32F205RC_SRAM128; STM32F205RC_XRC10_118MHZ
  OBJCOPY.OOCOutputFile: FISH_STM32F205RC_STM_118mhz_Debug_ddmmyyyy_hhmmss.v1.6.hex
  ILINK.IlinkOutputFile: FISH_STM32F205RC_STM_118mhz_Debug_ddmmyyyy_hhmmss.v1.6.out
  ILINK.IlinkIcfFile: stm32F205RC.icf
  group (top)
    ./: FISH_STM32F4_IAR.s main.c startup_stm32f4xx.s stm32f407xG.icf
